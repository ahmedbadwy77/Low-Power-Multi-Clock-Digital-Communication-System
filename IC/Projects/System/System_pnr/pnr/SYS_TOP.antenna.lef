

# LEF File for Accumulated Process Antenna Effects at the Boundary Pins
# *********************************************************************

VERSION 5.5 ;
DIVIDERCHAR "/" ;
BUSBITCHARS "[]" ;

MACRO SYS_TOP 
  PIN SI[3] 
    ANTENNAPARTIALMETALAREA 0.702 LAYER METAL2 ;
    ANTENNAPARTIALMETALSIDEAREA 3.37662 LAYER METAL2 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER VIA23 ;
    ANTENNAPARTIALMETALAREA 0.268 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 1.48148 LAYER METAL3 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER VIA34 ;
    ANTENNAPARTIALMETALAREA 0.154 LAYER METAL4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.93314 LAYER METAL4 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER VIA45 ;
    ANTENNAPARTIALMETALAREA 26.098 LAYER METAL5 ;
    ANTENNAPARTIALMETALSIDEAREA 125.724 LAYER METAL5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0533 LAYER METAL5 ; 
    ANTENNAMAXAREACAR 500.594 LAYER METAL5 ;
    ANTENNAMAXSIDEAREACAR 2421.64 LAYER METAL5 ;
    ANTENNAMAXCUTCAR 3.38649 LAYER VIA56 ;
  END SI[3]
  PIN SI[2] 
    ANTENNAPARTIALMETALAREA 0.734 LAYER METAL2 ;
    ANTENNAPARTIALMETALSIDEAREA 3.53054 LAYER METAL2 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER VIA23 ;
    ANTENNAPARTIALMETALAREA 0.154 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 0.93314 LAYER METAL3 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER VIA34 ;
    ANTENNAPARTIALMETALAREA 0.268 LAYER METAL4 ;
    ANTENNAPARTIALMETALSIDEAREA 1.48148 LAYER METAL4 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER VIA45 ;
    ANTENNAPARTIALMETALAREA 32.658 LAYER METAL5 ;
    ANTENNAPARTIALMETALSIDEAREA 157.277 LAYER METAL5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0533 LAYER METAL5 ; 
    ANTENNAMAXAREACAR 713.577 LAYER METAL5 ;
    ANTENNAMAXSIDEAREACAR 3446.09 LAYER METAL5 ;
    ANTENNAMAXCUTCAR 4.74109 LAYER VIA56 ;
  END SI[2]
  PIN SI[1] 
    ANTENNAPARTIALMETALAREA 1.317 LAYER METAL2 ;
    ANTENNAPARTIALMETALSIDEAREA 6.33477 LAYER METAL2 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER VIA23 ;
    ANTENNAPARTIALMETALAREA 2.131 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 10.4425 LAYER METAL3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0533 LAYER METAL3 ; 
    ANTENNAMAXAREACAR 160.613 LAYER METAL3 ;
    ANTENNAMAXSIDEAREACAR 779.115 LAYER METAL3 ;
    ANTENNAMAXCUTCAR 1.3546 LAYER VIA34 ;
  END SI[1]
  PIN SI[0] 
    ANTENNAPARTIALMETALAREA 9.162 LAYER METAL2 ;
    ANTENNAPARTIALMETALSIDEAREA 44.0692 LAYER METAL2 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER VIA23 ;
    ANTENNAPARTIALMETALAREA 1.325 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 6.56565 LAYER METAL3 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER VIA34 ;
    ANTENNAPARTIALMETALAREA 1.944 LAYER METAL4 ;
    ANTENNAPARTIALMETALSIDEAREA 9.54304 LAYER METAL4 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER VIA45 ;
    ANTENNAPARTIALMETALAREA 12.559 LAYER METAL5 ;
    ANTENNAPARTIALMETALSIDEAREA 60.6012 LAYER METAL5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0533 LAYER METAL5 ; 
    ANTENNAMAXAREACAR 318.605 LAYER METAL5 ;
    ANTENNAMAXSIDEAREACAR 1546.28 LAYER METAL5 ;
    ANTENNAMAXCUTCAR 3.38649 LAYER VIA56 ;
  END SI[0]
  PIN SO[3] 
    ANTENNADIFFAREA 0.537 LAYER METAL3 ; 
    ANTENNAPARTIALMETALAREA 2.642 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 12.9004 LAYER METAL3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.13 LAYER METAL3 ; 
    ANTENNAMAXAREACAR 36.9153 LAYER METAL3 ;
    ANTENNAMAXSIDEAREACAR 174.832 LAYER METAL3 ;
    ANTENNAMAXCUTCAR 3.01839 LAYER VIA34 ;
  END SO[3]
  PIN SO[2] 
    ANTENNAPARTIALMETALAREA 5.307 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 25.5267 LAYER METAL3 ;
    ANTENNAPARTIALCUTAREA 0.0361 LAYER VIA34 ;
    ANTENNAPARTIALMETALAREA 4.076 LAYER METAL4 ;
    ANTENNAPARTIALMETALSIDEAREA 19.798 LAYER METAL4 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER VIA45 ;
    ANTENNADIFFAREA 0.6 LAYER METAL5 ; 
    ANTENNAPARTIALMETALAREA 29.109 LAYER METAL5 ;
    ANTENNAPARTIALMETALSIDEAREA 140.207 LAYER METAL5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.1872 LAYER METAL5 ; 
    ANTENNAMAXAREACAR 192.859 LAYER METAL5 ;
    ANTENNAMAXSIDEAREACAR 929.33 LAYER METAL5 ;
    ANTENNAMAXCUTCAR 2.19672 LAYER VIA56 ;
  END SO[2]
  PIN SO[1] 
    ANTENNAPARTIALMETALAREA 7.632 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 36.7099 LAYER METAL3 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER VIA34 ;
    ANTENNAPARTIALMETALAREA 4.65 LAYER METAL4 ;
    ANTENNAPARTIALMETALSIDEAREA 22.5589 LAYER METAL4 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER VIA45 ;
    ANTENNADIFFAREA 0.537 LAYER METAL5 ; 
    ANTENNAPARTIALMETALAREA 19.224 LAYER METAL5 ;
    ANTENNAPARTIALMETALSIDEAREA 92.6599 LAYER METAL5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0702 LAYER METAL5 ; 
    ANTENNAMAXAREACAR 282.588 LAYER METAL5 ;
    ANTENNAMAXSIDEAREACAR 1367.91 LAYER METAL5 ;
    ANTENNAMAXCUTCAR 3.59972 LAYER VIA56 ;
  END SO[1]
  PIN SO[0] 
    ANTENNAPARTIALMETALAREA 3.901 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 18.7638 LAYER METAL3 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER VIA34 ;
    ANTENNAPARTIALMETALAREA 18.554 LAYER METAL4 ;
    ANTENNAPARTIALMETALSIDEAREA 89.4371 LAYER METAL4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0871 LAYER METAL4 ; 
    ANTENNAMAXAREACAR 222.347 LAYER METAL4 ;
    ANTENNAMAXSIDEAREACAR 1075.11 LAYER METAL4 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER VIA45 ;
    ANTENNAMAXCUTCAR 2.90126 LAYER VIA45 ;
    ANTENNADIFFAREA 0.6 LAYER METAL5 ; 
    ANTENNAPARTIALMETALAREA 27.483 LAYER METAL5 ;
    ANTENNAPARTIALMETALSIDEAREA 132.386 LAYER METAL5 ;
    ANTENNAGATEAREA 0.1534 LAYER METAL5 ; 
    ANTENNAMAXAREACAR 401.506 LAYER METAL5 ;
    ANTENNAMAXSIDEAREACAR 1938.12 LAYER METAL5 ;
    ANTENNAMAXCUTCAR 3.81146 LAYER VIA56 ;
  END SO[0]
  PIN REF_CLK 
    ANTENNAPARTIALMETALAREA 0.619 LAYER METAL2 ;
    ANTENNAPARTIALMETALSIDEAREA 2.97739 LAYER METAL2 ;
    ANTENNAPARTIALCUTAREA 0.0361 LAYER VIA23 ;
    ANTENNAPARTIALMETALAREA 2.108 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 10.3319 LAYER METAL3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 3.0628 LAYER METAL3 ; 
    ANTENNAMAXAREACAR 0.823299 LAYER METAL3 ;
    ANTENNAMAXSIDEAREACAR 4.043 LAYER METAL3 ;
    ANTENNAMAXCUTCAR 0.0235732 LAYER VIA34 ;
  END REF_CLK
  PIN UART_CLK 
    ANTENNAPARTIALMETALAREA 0.351 LAYER METAL2 ;
    ANTENNAPARTIALMETALSIDEAREA 1.68831 LAYER METAL2 ;
    ANTENNAPARTIALCUTAREA 0.0361 LAYER VIA23 ;
    ANTENNAPARTIALMETALAREA 0.632 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 3.23232 LAYER METAL3 ;
    ANTENNAPARTIALCUTAREA 0.0361 LAYER VIA34 ;
    ANTENNAPARTIALMETALAREA 0.796 LAYER METAL4 ;
    ANTENNAPARTIALMETALSIDEAREA 4.02116 LAYER METAL4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 3.0628 LAYER METAL4 ; 
    ANTENNAMAXAREACAR 0.895782 LAYER METAL4 ;
    ANTENNAMAXSIDEAREACAR 4.45446 LAYER METAL4 ;
    ANTENNAMAXCUTCAR 0.0353598 LAYER VIA45 ;
  END UART_CLK
  PIN RST_N 
    ANTENNAPARTIALMETALAREA 1.549 LAYER METAL2 ;
    ANTENNAPARTIALMETALSIDEAREA 7.45069 LAYER METAL2 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER VIA23 ;
    ANTENNAPARTIALMETALAREA 2.801 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 13.6652 LAYER METAL3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0533 LAYER METAL3 ; 
    ANTENNAMAXAREACAR 97.0919 LAYER METAL3 ;
    ANTENNAMAXSIDEAREACAR 470.766 LAYER METAL3 ;
    ANTENNAMAXCUTCAR 2.03189 LAYER VIA34 ;
  END RST_N
  PIN UART_RX_IN 
    ANTENNAPARTIALMETALAREA 0.216 LAYER METAL2 ;
    ANTENNAPARTIALMETALSIDEAREA 1.03896 LAYER METAL2 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER VIA23 ;
    ANTENNAPARTIALMETALAREA 0.548 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 2.82828 LAYER METAL3 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER VIA34 ;
    ANTENNAPARTIALMETALAREA 0.892 LAYER METAL4 ;
    ANTENNAPARTIALMETALSIDEAREA 4.48292 LAYER METAL4 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER VIA45 ;
    ANTENNAPARTIALMETALAREA 11.256 LAYER METAL5 ;
    ANTENNAPARTIALMETALSIDEAREA 54.3338 LAYER METAL5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.4407 LAYER METAL5 ; 
    ANTENNAMAXAREACAR 55.0115 LAYER METAL5 ;
    ANTENNAMAXSIDEAREACAR 258.957 LAYER METAL5 ;
    ANTENNAMAXCUTCAR 1.46996 LAYER VIA56 ;
  END UART_RX_IN
  PIN scan_clk 
    ANTENNAPARTIALMETALAREA 0.255 LAYER METAL2 ;
    ANTENNAPARTIALMETALSIDEAREA 1.22655 LAYER METAL2 ;
    ANTENNAPARTIALCUTAREA 0.0361 LAYER VIA23 ;
    ANTENNAPARTIALMETALAREA 1.288 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 6.38768 LAYER METAL3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 3.0628 LAYER METAL3 ; 
    ANTENNAMAXAREACAR 0.55557 LAYER METAL3 ;
    ANTENNAMAXSIDEAREACAR 2.75522 LAYER METAL3 ;
    ANTENNAMAXCUTCAR 0.0235732 LAYER VIA34 ;
  END scan_clk
  PIN scan_rst 
    ANTENNAPARTIALMETALAREA 0.633 LAYER METAL2 ;
    ANTENNAPARTIALMETALSIDEAREA 3.04473 LAYER METAL2 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER VIA23 ;
    ANTENNAPARTIALMETALAREA 17.101 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 82.4482 LAYER METAL3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.1599 LAYER METAL3 ; 
    ANTENNAMAXAREACAR 119.181 LAYER METAL3 ;
    ANTENNAMAXSIDEAREACAR 574.607 LAYER METAL3 ;
    ANTENNAMAXCUTCAR 2.03189 LAYER VIA34 ;
  END scan_rst
  PIN test_mode 
    ANTENNAPARTIALMETALAREA 2.993 LAYER METAL2 ;
    ANTENNAPARTIALMETALSIDEAREA 14.3963 LAYER METAL2 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER VIA23 ;
    ANTENNAPARTIALMETALAREA 0.268 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 1.48148 LAYER METAL3 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER VIA34 ;
    ANTENNAPARTIALMETALAREA 5.21 LAYER METAL4 ;
    ANTENNAPARTIALMETALSIDEAREA 25.4449 LAYER METAL4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.9334 LAYER METAL4 ; 
    ANTENNAMAXAREACAR 21.2728 LAYER METAL4 ;
    ANTENNAMAXSIDEAREACAR 101.874 LAYER METAL4 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER VIA45 ;
    ANTENNAMAXCUTCAR 0.547614 LAYER VIA45 ;
    ANTENNAPARTIALMETALAREA 7.493 LAYER METAL5 ;
    ANTENNAPARTIALMETALSIDEAREA 36.2337 LAYER METAL5 ;
    ANTENNAGATEAREA 2.5428 LAYER METAL5 ; 
    ANTENNAMAXAREACAR 24.2195 LAYER METAL5 ;
    ANTENNAMAXSIDEAREACAR 116.123 LAYER METAL5 ;
    ANTENNAMAXCUTCAR 1.10446 LAYER VIA56 ;
  END test_mode
  PIN SE 
    ANTENNAPARTIALMETALAREA 4.788 LAYER METAL2 ;
    ANTENNAPARTIALMETALSIDEAREA 23.0303 LAYER METAL2 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.2314 LAYER METAL2 ; 
    ANTENNAMAXAREACAR 22.8284 LAYER METAL2 ;
    ANTENNAMAXSIDEAREACAR 109.247 LAYER METAL2 ;
    ANTENNAPARTIALCUTAREA 0.1444 LAYER VIA23 ;
    ANTENNAMAXCUTCAR 0.936041 LAYER VIA23 ;
    ANTENNAPARTIALMETALAREA 1.069 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 5.52669 LAYER METAL3 ;
    ANTENNAGATEAREA 0.5785 LAYER METAL3 ; 
    ANTENNAMAXAREACAR 24.6763 LAYER METAL3 ;
    ANTENNAMAXSIDEAREACAR 118.801 LAYER METAL3 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER VIA34 ;
    ANTENNAMAXCUTCAR 1.06085 LAYER VIA34 ;
    ANTENNAPARTIALMETALAREA 0.168 LAYER METAL4 ;
    ANTENNAPARTIALMETALSIDEAREA 1.00048 LAYER METAL4 ;
    ANTENNAGATEAREA 0.5785 LAYER METAL4 ; 
    ANTENNAMAXAREACAR 24.9667 LAYER METAL4 ;
    ANTENNAMAXSIDEAREACAR 120.53 LAYER METAL4 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER VIA45 ;
    ANTENNAMAXCUTCAR 1.18565 LAYER VIA45 ;
    ANTENNAPARTIALMETALAREA 10.682 LAYER METAL5 ;
    ANTENNAPARTIALMETALSIDEAREA 51.5728 LAYER METAL5 ;
    ANTENNAGATEAREA 1.0387 LAYER METAL5 ; 
    ANTENNAMAXAREACAR 121.936 LAYER METAL5 ;
    ANTENNAMAXSIDEAREACAR 591.286 LAYER METAL5 ;
    ANTENNAMAXCUTCAR 3.54338 LAYER VIA56 ;
  END SE
  PIN UART_TX_O 
    ANTENNAPARTIALMETALAREA 6.143 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 29.7402 LAYER METAL3 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER VIA34 ;
    ANTENNAPARTIALMETALAREA 0.154 LAYER METAL4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.93314 LAYER METAL4 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER VIA45 ;
    ANTENNADIFFAREA 0.571 LAYER METAL5 ; 
    ANTENNAPARTIALMETALAREA 10.518 LAYER METAL5 ;
    ANTENNAPARTIALMETALSIDEAREA 50.784 LAYER METAL5 ;
  END UART_TX_O
  PIN parity_error 
    ANTENNAPARTIALMETALAREA 0.661 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 3.17941 LAYER METAL3 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER VIA34 ;
    ANTENNAPARTIALMETALAREA 0.25 LAYER METAL4 ;
    ANTENNAPARTIALMETALSIDEAREA 1.3949 LAYER METAL4 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER VIA45 ;
    ANTENNADIFFAREA 0.6 LAYER METAL5 ; 
    ANTENNAPARTIALMETALAREA 24.107 LAYER METAL5 ;
    ANTENNAPARTIALMETALSIDEAREA 116.147 LAYER METAL5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.2587 LAYER METAL5 ; 
    ANTENNAMAXAREACAR 129.288 LAYER METAL5 ;
    ANTENNAMAXSIDEAREACAR 624.199 LAYER METAL5 ;
    ANTENNAMAXCUTCAR 1.51456 LAYER VIA56 ;
  END parity_error
  PIN framing_error 
    ANTENNADIFFAREA 0.524 LAYER METAL3 ; 
    ANTENNAPARTIALMETALAREA 4.005 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 19.2641 LAYER METAL3 ;
  END framing_error
END SYS_TOP

END LIBRARY
